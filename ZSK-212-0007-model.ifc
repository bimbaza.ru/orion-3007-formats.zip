Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:47+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-212-0007
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-212-0007 Тематический комплекс (Корабль) «Морской Исследователь»
In: Площадка
Description: Оборудование благоустройства. Тематический комплекс (Корабль) «Морской Исследователь»; Classification: 59.1.15.01-0774 Корабль (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-212-0007; ModelReference: Тематический комплекс (Корабль) «Морской Исследователь»; ProductionYear: 2026; ArticleNumber: ZSK-212-0007
ORION_Изделие - Артикул: ZSK-212-0007; Артикул прежний: SD-212-0007; Наименование: Тематический комплекс (Корабль) «Морской Исследователь»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 9.1 x 5.8 м; Зона безопасности: 12.5 x 9.4 м; Высота свободного падения: 1.5 м; Возраст: для детей от 5 до 12 лет; Цена: 5 541 520 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/transport/3007; Код КСИ: CPr>EDB090; Класс КСИ: Корабль; Коды КСР: 59.1.15.01-0774 … 59.1.15.01-0785
ADSK - ADSK_Наименование: Тематический комплекс (Корабль) «Морской Исследователь»; ADSK_Марка: ZSK-212-0007; ADSK_Код изделия: 59.1.15.01-0774; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/transport/3007
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 5 до 12 лет; ZSK_Зона_безопасности: 12.5 x 9.4 м; ZSK_Высота_свободного_падения: 1.5 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB090; ZSK_Артикул_прежний: SD-212-0007
Qto_ORION - Длина: 9100 mm; Ширина: 5800 mm; Высота: 0 mm
